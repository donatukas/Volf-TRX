# Keil uVision project WOLF-Lite.uvprojx, settings and files
target WOLF-Lite-ILI9481_IPS (6190000::V6.19::ARMCLANG)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: WOLF-Lite-ILI9481_IPS +hex
  AfterMake: $K\ARM\ARMCLANG\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=5 OneElfS=1 uC99=1 v6Lang=5 v6LangP=7 v6Lto=1 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx,FRONTPANEL_LITE,LCD_ILI9481_IPS,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,ARM_MATH_LOOPUNROLL
  c misc: -Wno-sign-conversion -Wno-implicit-int-conversion -Wno-float-equal -Wno-sign-compare -Wno-gnu-flexible-array-initializer -pipe  -Wno-unused-value -Wdouble-promotion
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Core/Src;../../Src;../../Src/USBDevice;../../Src/JPEG
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  scatter file: .\WOLF-Lite\WOLF-Lite-custom.sct
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: hardware.c hardware.h front_unit.c fpga.c lcd.c rf_unit.c main.c stm32f4xx_it.c stm32f4xx_hal_msp.c
    ../Core/Inc/: main.h
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_sram.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Src
    ../../Src/: adpcm-lib.c adpcm-lib.h agc.c agc.h atu.c atu.h audio_filters.c audio_filters.h audio_processor.c audio_processor.h auto_calibration.c auto_calibration.h auto_notch.c auto_notch.h bands.c bands.h bootloader.c bootloader.h callsign.c callsign.h codec.c codec.h codec_nau8822.c codec_wm8731.c color_themes.h cw.c cw.h cw_decoder.h decoder.c decoder.h events.c events.h fft.c fft.h filemanager.c filemanager.h fonts.c fonts.h fpga.h front_unit.h functions.c functions.h i2c.c i2c.h images.c images.h INA226_PWR_monitor.c INA226_PWR_monitor.h lcd.h lcd_driver.c lcd_driver.h lcd_driver_ILI9481.c lcd_driver_ILI9481.h lcd_driver_NONE.c lcd_driver_NONE.h lcd_driver_RA8875.c lcd_driver_RA8875.h lcd_driver_ST7735S.c lcd_driver_ST7735S.h locator.c locator.h noise_blanker.c noise_blanker.h noise_reduction.c noise_reduction.h pre_distortion.c pre_distortion.h print.h profiler.c profiler.h rds_decoder.h rf_unit.h rtty_decoder.c rtty_decoder.h screen_layout.h screen_layout_480x320.cpp sd.c sd.h self_test.c self_test.h settings.c settings.h snap.c snap.h spec_analyzer.c spec_analyzer.h swr_analyzer.c swr_analyzer.h system_menu.c system_menu.h touchpad.c touchpad.h touchpad_GT911.c touchpad_GT911.h trx_manager.c trx_manager.h usbd_audio_if.c usbd_audio_if.h usbd_cat_if.c usbd_cat_if.h usbd_debug_if.c usbd_debug_if.h usbd_iq_if.c usbd_iq_if.h usbd_storage_if.c usbd_storage_if.h usbd_ua3reo.c usbd_ua3reo.h vad.c vad.h vocoder.c vocoder.h wifi.c wifi.h wspr.c wspr.h cw_decoder.c
  group Src/BiquadDesigner
    ../../Src/BiquadDesigner/: biquad.c biquad.h
  group Src/USBDevice
    ../../Src/USBDevice/: usb_device.c usb_device.h usbd_conf.c usbd_conf.h usbd_core.c usbd_core.h usbd_ctlreq.c usbd_ctlreq.h usbd_def.h usbd_desc.c usbd_desc.h usbd_ioreq.c usbd_ioreq.h
target WOLF-Lite-ILI9486 (6190000::V6.19::ARMCLANG)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: as above
  output: WOLF-Lite-ILI9486
  AfterMake: $K\ARM\ARMCLANG\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=5 OneElfS=1 uC99=1 v6Lang=5 v6LangP=7 v6Lto=1 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx,FRONTPANEL_LITE,LCD_ILI9486,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,ARM_MATH_LOOPUNROLL
  c misc: as above
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  scatter file: .\WOLF-Lite\WOLF-Lite-custom.sct
target WOLF-Lite-ILI9486_ALEX (6190000::V6.19::ARMCLANG)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: as above
  output: WOLF-Lite-ILI9486-ALEX
  AfterMake: $K\ARM\ARMCLANG\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=5 OneElfS=1 uC99=1 v6Lang=5 v6LangP=7 v6Lto=1 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx,FRONTPANEL_LITE,FRONTPANEL_LITE_ALEX,LCD_ILI9486,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,ARM_MATH_LOOPUNROLL
  c misc: as above
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  scatter file: .\WOLF-Lite\WOLF-Lite-custom.sct
software components: CMSIS:CORE 5.6.0, CMSIS:DSP 1.14.3
